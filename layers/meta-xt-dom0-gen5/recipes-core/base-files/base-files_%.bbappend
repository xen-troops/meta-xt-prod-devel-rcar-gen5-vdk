FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append:spider = " \
    file://fstab \
"
