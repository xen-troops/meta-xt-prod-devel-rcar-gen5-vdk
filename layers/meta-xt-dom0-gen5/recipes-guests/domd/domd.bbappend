FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI = "\
    file://${XT_DOMD_CONFIG_NAME} \
    file://domd.service \
"
