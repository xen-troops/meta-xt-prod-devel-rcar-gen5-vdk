FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:remove = " file://domu-vdevices.cfg"
