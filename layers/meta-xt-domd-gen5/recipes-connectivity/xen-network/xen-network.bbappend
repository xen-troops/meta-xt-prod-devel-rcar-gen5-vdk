FILES:${PN}:append = " ${sysconfdir}/systemd/network/eth0.network "
