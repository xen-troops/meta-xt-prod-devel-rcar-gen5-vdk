require xt-rcar-image.inc
