IMAGE_INSTALL += " devmem2"

IMAGE_INSTALL += " e2fsprogs"
